# Keil uVision project tst.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: tst +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\stm32-tst2;.\RTE\Device\STM32F103C8
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: config.c main.c config.h interrupts.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/Device/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dac.c
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
